options:
  parameters:
    author: labcom
    generate_options: qt_gui
    id: PSD_random_signal
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: h
  id: variable
  parameters:
    value: np.ones((Sps,), dtype=int)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Sps*Rb
  states: {}
- name: Menu
  id: qtgui_tab_widget
  parameters:
    label0: Time & Freq
    label1: Freq
    num_tabs: '2'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '-500e-3'
    type: float
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '76'
    type: float
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: '1024'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /home/labcom/Documentos/campoç/lab 3/Archivos a usar/Rojo.jpg
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: N*[1/(N*samp_rate)]
    type: float
    vlen: N
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '128000'
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    N: '1024'
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n\n\n    def __init__(self, N=1024):  # only default arguments here\n        gr.sync_block.__init__(\n            self,\n            name='e_vec_averager_ff',   # will show up in GRC\n            in_sig=[(np.float32,N)],\n            out_sig=[(np.float32,N)]\n        )\n        self.N =N\n        self.rows_counter = 0\n        self.sum = 0\n\n    def work(self, input_items, output_items):\n        x = input_items[0]\n        y = output_items[0]\n        self.sum += np.sum(x,axis = 0)\n        self.rows_counter += len(x)\n        y[:] = self.sum/self.rows_counter\n        return len(output_items[0])\n        \n        \n        \n        \n        \n\n"
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: float
    window: '[ 1]*N'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h
    type: fff
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '64'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.2'
    vlen: N
    x_axis_label: '"f"'
    x_start: '-samp_rate/2'
    x_step: samp_rate/N
    x_units: '"Hz"'
    y_axis_label: '"Sx(f)"'
    y_units: '"W/Hz"'
    ymax: 1/Rb
    ymin: '0'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: p4
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: p5
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: p3
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: p5
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: p4
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_noise_source_x_0, '0', virtual_sink_1, '0']
- [analog_random_source_x_0, '0', blocks_char_to_float_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_xx_0, '1']
- [blocks_char_to_float_0, '0', virtual_sink_2, '0']
- [blocks_complex_to_mag_squared_1, '0', epy_block_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_file_source_1, '0', blocks_unpack_k_bits_bb_1, '0']
- [blocks_multiply_const_vxx_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_2, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', blocks_char_to_float_0, '0']
- [epy_block_0, '0', blocks_multiply_const_vxx_2, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_1, '0']
- [interp_fir_filter_xxx_0, '0', blocks_throttle_0, '0']
- [virtual_source_0, '0', blocks_null_sink_0, '0']
- [virtual_source_1, '0', blocks_stream_to_vector_0, '0']
- [virtual_source_1, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_1, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
